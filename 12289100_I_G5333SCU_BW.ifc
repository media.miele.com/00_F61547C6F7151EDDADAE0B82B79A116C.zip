Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-22T12:46:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 22 12:46:13 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7b3ee4da-c21c-4361-b68a-f795bfa2d582\2bdd7bdc-d64e-4b96-ae84-6aae7e014535\ifc * Database version: 5507 * Database creation date: Wed Feb 22 12:46:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 22 12:46:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 22 12:46:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12289100_I_G5333SCU_BW:21533336_I_12289100_G5333SCU_BW, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 21533336_I_12289100_G5333SCU_BW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 21533336_I_12289100_G5333SCU_BW
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 805 mm; Depth: 570 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_357483
Description: Flow; FlowDirection: SOURCEANDSINK
